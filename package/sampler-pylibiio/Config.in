## package/sampler-pylibiio/Config.in
```kconfig
config BR2_PACKAGE_SAMPLER_PYLIBIIO
    bool "sampler pylibiio"
    help
      LibIIO v1.0 Python bindings
```
